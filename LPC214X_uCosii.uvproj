# Keil uVision project LPC214X_uCosii.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LPC214X_uCosii +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\APP\mem_a.scf
  group ARM
    ./ARM/: Os_cpu_c.c Os_cpu_a.s
  group uCOS-II
    ./uCosii/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group MD2148
    ./APP/: target.c IRQ.s Startup.s uart.c rtc.c led.c lcd.c delay.c kbd.c relay.c adc.c
  group Main
    C:/Users/omkar/Downloads/: ISE2_project.c
